# IAR project Backup (1) of SIP_App.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070CB ST STM32G070CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G070xx
  ICCARM.CCDiagSuppress: Pe174
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\Libraries; ..\Libraries\System; ..\Libraries\User; ..\Libraries\User\Main; ..\Libraries\User\RSA; ..\Libraries\User\RSA\common; ..\Libraries\User\RSA\Crypto
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Debug\Exe\S500_App - V1.4.6.3 - 250426.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\Libraries\System\stm32g070xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EWARM
    ../Libraries/User/Main/: general_functions.c main.c System_Interrupts.c System_Utility.c
  group Libraries/System
    ../Libraries/System/: startup_stm32g070xx.s system_stm32g0xx.c
  group Libraries/User/A2D
    ../Libraries/User/ADC/: ADC_Config.c
  group Libraries/User/Accelerometer
    ../Libraries/User/Accelerometer/: accel_i2c.c dev_attachment.c KX023.c
  group Libraries/User/Flash
    ../Libraries/User/Flash/: Flash.c
  group Libraries/User/GPS
    ../Libraries/User/GPS/: GPS.c GPS_USART.c
  group Libraries/User/GSM
    ../Libraries/User/GSM/: GSM_BT.c GSM_Utility.c HTTP_Process.c Module_USART.c SMS_Process.c SSL_Process.c
  group Libraries/User/IOs
    ../Libraries/User/Digital_IO/: Digital_IO.c
  group Libraries/User/Protocol
    ../Libraries/User/SIP_Protocol/: circular_buffer.c sip_protocol.c system.c
  group Libraries/User/RSA
    ../Libraries/User/RSA/: RSA_Cryptographic.c
  group Libraries/User/RSA/Certificate
    ../Libraries/User/RSA/Crypto/certificate/: pem_import.c x509_cert_parse.c x509_cert_validate.c x509_common.c
  group Libraries/User/RSA/Common
    ../Libraries/User/RSA/common/: cpu_endian.c date_time.c debug.c os_port_none.c resource_manager.c str.c
  group Libraries/User/RSA/Encoding
    ../Libraries/User/RSA/Crypto/encoding/: asn1.c base64.c oid.c
  group Libraries/User/RSA/Hash
    ../Libraries/User/RSA/Crypto/hash/: md5.c
  group Libraries/User/RSA/MPI
    ../Libraries/User/RSA/Crypto/mpi/: mpi.c
  group Libraries/User/RSA/PKC
    ../Libraries/User/RSA/Crypto/pkc/: dh.c dsa.c rsa.c
  group Libraries/User/SPIF
    ../Libraries/User/SPIF/: SPIF.c SPIF_Driver.c SPIF_spi.c
  group Libraries/User/Timers
    ../Libraries/User/Timers/: LEDs.c System_Timers.c
